# Keil uVision project proj.uvprojx, settings and files
target Transmitter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: expf_test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT, CODE_TRANSMITTER
  c include: D:\ProgramData\TI\TivaWare_C_Series-2.1.4.178
  asm include: D:\ProgramData\TI\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: main_receiver.c main_transmitter.c common.h common.c ui.h ui.c music.h music.c
  group Library
    ./: ADC.h ADC.c LM75BD.h LM75BD.c JLX12864G.h tm1638.h tm1638.c JLX12864G.c
    D:/ProgramData/TI/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
target Receiver (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: expf_test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT, CODE_RECEIVER
  c include: D:\ProgramData\TI\TivaWare_C_Series-2.1.4.178
  asm include: D:\ProgramData\TI\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: Device:Startup 1.0.0
